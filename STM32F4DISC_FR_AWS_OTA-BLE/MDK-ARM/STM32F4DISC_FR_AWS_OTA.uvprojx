# Keil uVision project STM32F4DISC_FR_AWS_OTA.uvprojx, settings and files
target STM32F4DISC_FR_AWS_OTA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4DISC_FR_AWS_OTA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,DEBUG_USART
  c include: ..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Inc;..\eng\atm;..\eng\dev_sign;..\eng\dynamic_register;..\eng\infra;..\eng\mqtt;..\eng\ota;..\eng\wrappers\external_libs;..\eng\wrappers;..\eng\external_libs\mbedtls;..\eng\external_libs\nghttp2;..\eng\external_libs\mbedtls\include\mbedtls;..\eng\dev_model;..\eng;..\eng\infra;..\eng\atm
  asm include: ..\Inc\include;..\Inc\include\exports;..\Inc\include\imports
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c ota_example_mqtt.c sim8001.c
    ./: ble_chat_to_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group atm
    ../eng/atm/: at_api.c at_conn_mbox.c at_conn_mgmt.c at_parser.c at_tcp.c sim800.c mqtt_sim800.c at_mqtt.c
    ../Src/: hal_sim800.c hal_ota.c
  group dev_sign
    ../eng/dev_sign/: dev_sign_mqtt.c
  group infra
    ../eng/infra/: infra_compat.c infra_defs.c infra_httpc.c infra_json_parser.c infra_log.c infra_md5.c infra_net.c infra_prt_nwk_payload.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
  group mqtt
    ../eng/mqtt/: mqtt_api.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group wrappers
    ../eng/wrappers/: wrapper.c
  group ota
    ../eng/ota/: ota_mqtt.c iotx_ota.c ota_lib.c ota_coap.c ota_fetch.c
  group certs
    ../eng/certs/: root_ca.c
software components: CMSIS:CORE 5.1.2
